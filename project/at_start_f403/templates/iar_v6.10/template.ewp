# IAR project template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32F403ZGT6_v2 ArteryTek -AT32F403ZGT6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: AT32F403ZGT6; USE_STDPERIPH_DRIVER; AT_START_F403_V1
  ICCARM.CCIncludePath2: ..\..\..\..\libraries\drivers\inc; core_support; ..\..\..\..\libraries\cmsis\cm4\device_support; ..\..\..\at32f403_board; ..\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.hex
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ArteryTek\AT32F403xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group bsp
    ../../../at32f403_board/: at32f403_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f403.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f403.c
  group firmware
    ../../../../libraries/drivers/src/: at32f403_adc.c at32f403_bpr.c at32f403_can.c at32f403_crc.c at32f403_crm.c at32f403_dac.c at32f403_debug.c at32f403_dma.c at32f403_exint.c at32f403_flash.c at32f403_gpio.c at32f403_i2c.c at32f403_misc.c at32f403_pwc.c at32f403_rtc.c at32f403_sdio.c at32f403_spi.c at32f403_tmr.c at32f403_usart.c at32f403_usb.c at32f403_wdt.c at32f403_wwdt.c at32f403_xmc.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32f403_clock.c at32f403_int.c main.c
