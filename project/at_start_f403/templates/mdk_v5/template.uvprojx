# Keil uVision project template.uvprojx, settings and files
target template (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: -AT32F403ZGT6 ArteryTek
  pack: ArteryTek.AT32F403_DFP.2.0.3
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403ZGT6,USE_STDPERIPH_DRIVER,AT_START_F403_V1
  c include: ..\..\..\..\libraries\drivers\inc;..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\at32f403_board
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: at32f403_clock.c at32f403_int.c main.c
  group bsp
    ../../../at32f403_board/: at32f403_board.c
  group firmware
    ../../../../libraries/drivers/src/: at32f403_adc.c at32f403_bpr.c at32f403_can.c at32f403_crc.c at32f403_crm.c at32f403_dac.c at32f403_debug.c at32f403_dma.c at32f403_exint.c at32f403_flash.c at32f403_gpio.c at32f403_i2c.c at32f403_misc.c at32f403_pwc.c at32f403_rtc.c at32f403_sdio.c at32f403_spi.c at32f403_tmr.c at32f403_usart.c at32f403_usb.c at32f403_wdt.c at32f403_wwdt.c at32f403_xmc.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f403.c
    ../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f403.s
  group readme
    ../: readme.txt
