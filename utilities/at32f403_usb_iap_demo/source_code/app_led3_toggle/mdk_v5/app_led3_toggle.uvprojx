# Keil uVision project app_led3_toggle.uvprojx, settings and files
target app_led3_toggle (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: -AT32F403ZGT6 ArteryTek
  pack: ArteryTek.AT32F403_DFP.2.0.3
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: app_led3_toggle +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403ZGT6,USE_STDPERIPH_DRIVER,AT_START_F403_V1
  c include: ..\inc;..\..\..\..\..\project\at32f403_board;..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\..\middlewares\usbd_drivers\inc;..\..\..\..\..\middlewares\usbd_class\hid_iap
  memory RVCT4: ROM 0x8004000 size 0xfc000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: at32f403_clock.c at32f403_int.c hid_iap_user.c main.c
  group bsp
    ../../../../../project/at32f403_board/: at32f403_board.c
  group firmware
    ../../../../../libraries/drivers/src/: at32f403_crc.c at32f403_crm.c at32f403_usart.c at32f403_flash.c at32f403_gpio.c at32f403_misc.c at32f403_usb.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32f403.c
    ../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f403.s
  group usbd_drivers
    ../../../../../middlewares/usbd_drivers/src/: usbd_core.c usbd_int.c usbd_sdr.c
  group usbd_class
    ../../../../../middlewares/usbd_class/hid_iap/: hid_iap_class.c hid_iap_desc.c
  group readme
    ../: readme.txt
